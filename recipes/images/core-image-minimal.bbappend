# Append telaf related images to make the sdk generation via open source projects include vsomeip

CORE_IMAGE_EXTRA_INSTALL += "vsomeip"
