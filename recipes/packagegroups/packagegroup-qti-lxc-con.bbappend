# Append LXC telaf build related bb files

RDEPENDS_packagegroup-qti-lxc-con += "telaf-lxc-build"
