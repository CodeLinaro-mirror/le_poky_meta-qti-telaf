RDEPENDS_${PN}_append = "\
        policycoreutils-genhomedircon \
        policycoreutils-loadpolicy \
        policycoreutils-runinit \
        policycoreutils-setsebool \
        policycoreutils-hll \
"

