# Append telaf related nativesdk packages.

RDEPENDS_${PN}_qti-distro-base += "\
    nativesdk-capicxx-core \
    nativesdk-capicxx-someip \
    "
